$NOMOD51
NAME ?C_STARTUP

?C_C51STARTUP SEGMENT CODE
?STACK SEGMENT IDATA

RSEG ?STACK
DS 1

EXTRN CODE (?C_START)
PUBLIC ?C_STARTUP

CSEG AT 0
?C_STARTUP:
    LJMP STARTUP1

RSEG ?C_C51STARTUP
STARTUP1:
    MOV 0A0H,#00H
    MOV 080H,#00H
    MOV 0A0H,#0A0H
    NOP
    MOV 0A0H,#00H

    MOV 080H,#00H
    MOV 0A0H,#0C0H
    NOP
    MOV 0A0H,#00H

    MOV 080H,#0FFH
    MOV 0A0H,#0E0H
    NOP
    MOV 0A0H,#00H

    MOV 080H,#0FFH
    MOV 0A0H,#080H
    NOP

    MOV R0,#07FH
    CLR A
CLEAR_RAM:
    MOV @R0,A
    DJNZ R0,CLEAR_RAM
    MOV 081H,#?STACK-1
    LJMP ?C_START

END
